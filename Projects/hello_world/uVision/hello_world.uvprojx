# Keil uVision project hello_world.uvprojx, settings and files
target HelloWorld (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Include;..\..\..\Include\BSP;..\..\..\BSP;..\..\..\BSP\CPU\LPC1768\internal;..\..\..\Kernel;..\..\..\Kernel\Scheduler;..\..\..\Environment\Tools\Debug;..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Driver + HAL
    ../../../BSP/CPU/LPC1768/internal/: startup_LPC17xx.s system_LPC17xx.c
    ../../../BSP/Board/LandTiger/: Board.c Drv_LED.c
    ../../../BSP/CPU/LPC1768/: Drv_CPUCore.c Drv_CPUCore_Assembly.c Drv_GPIO.c Drv_Timer.c
  group OS
    ../../../Kernel/: Kernel.c
    ../../../Kernel/Scheduler/NonePreemptiveRR/: Scheduler.c
  group Projects
    ../: main.c
